## config/boards/shields/voidPointer/Kconfig.shield
```kconfig
# Copyright (c) 2024
# SPDX-License-Identifier: MIT

config SHIELD_VOIDPOINTER
    def_bool $(shields_list_contains,voidPointer)
```
